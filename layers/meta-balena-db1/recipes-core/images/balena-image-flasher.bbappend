include balena-image.inc

IMAGE_ROOTFS_MAXSIZE="2000000"
